Properties of the parts of a building model (IFC2X3)

# File
Description: Temperaturregler, Wandmontage, 0…60 °C, Hysterese einstellbar 2…20 K, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: JA046200, Temperaturregler, Wandmontage, 0…60 °C, Hysterese einstellbar 2…20 K, Inneneinstellung
In: Raum
Description: Regelung oder Überwachung der Temperatur im industriellen Bereich in nicht aggressiver Umgebung, z. B. zur Ansteuerung von Heizungs- oder Klimaanlagen in Gewächshäusern, Industrie-, Sport- und Traglufthallen, Kühl- und Tiefkühlräumen.; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: JA046200; ModelLabel: JET-120 RF; GlobalTradeItemNumber: 4050528047069; ProductURL: https://alre.de/produkt_JA046200
Pset_Specification - NominalLength: 0.165 m; NominalWidth: 0.083 m; NominalDepth: 0.071 m; NetWeight: 0.354
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 70; Ausführung des Sensors: Kapillarrohr; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Elektronische Ausführung: no; Geeignet als Wächter: yes; Mediumtemperatur: -35; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-JA046200.pdf
